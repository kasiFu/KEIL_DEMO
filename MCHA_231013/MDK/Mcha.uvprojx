# Keil uVision project Mcha.uvprojx, settings and files
target BAT32A237 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: BAT32A237KH48FA Cmsemicon
  pack: Cmsemicon.BAT32A237.1.0.5
  cpu: IRAM(0x20000000,0x03000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,BAT32G137_64PIN
  c include: ..\RteM\include;..\bsw;..\bsw\EcuM;..\bsw\input;..\bsw\Mcu;..\swc\include;..\Device\Include;..\Driver\include;..\Fbl\BootCfg;..\Fbl\Common;..\Fbl\DebugSystem;..\Fbl\linSendReceive;..\Fbl\TimeSystem;..\Fbl\UDS_Stcak\UDS_APP;..\Fbl\UDS_Stcak\UDS_LIN_TP;..\Fbl\SecM;..\Fbl\Cal
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group MAIN
    ../: main.c
  group BSW
    ../Driver/src/: intp.c uart.c sci_common.c tim.c dma.c cgc.c gpio.c wdt.c delay.c flash.c adc.c isr.c
    ../Fbl/linSendReceive/: lin_protocol.c
    ../bsw/EcuM/: EcuM.c EcuM_Callout_Stubs.c
    ../bsw/Mcu/: Mcu.c
    ../bsw/input/: Analog.c
  group SWC
    ../Fbl/BootCfg/: BootCfg.c
    ../Fbl/DebugSystem/: Debug.c
    ../Fbl/TimeSystem/: timer_hal.c
    ../Fbl/UDS_Stcak/UDS_APP/: uds_alg_hal.c
    ../Fbl/linSendReceive/: delay_drv.c dma_drv.c intp_drv.c tim_drv.c uart_drv.c
    ../Driver/src/: tima.c
    ../: udslib.a
    ../Fbl/Cal/: Cal.c
    ../Fbl/SecM/: SecM.c
    ../swc/src/: keyScan.c Massage.c Massage_cfg.c
  group Rte
    ../RteM/src/: Rte.c Rte_Cfg.c
software components: CMSIS:CORE 5.4.0, Device:ISR 1.0.0, Device:Startup 1.0.0
